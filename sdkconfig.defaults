## sdkconfig.defaults
```kconfig
CONFIG_LWIP_TCP_WND_DEFAULT=65535
CONFIG_LWIP_TCP_SND_BUF_DEFAULT=32768
CONFIG_LWIP_TCP_MSS=1460
CONFIG_LWIP_TCP_SND_QUEUELEN=64
```
